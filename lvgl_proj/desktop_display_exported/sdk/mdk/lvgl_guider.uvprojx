# Keil uVision project lvgl_guider.uvprojx, settings and files
target lvgl_guider debug (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: lvgl_guider.out
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG, CPU_MCXN947VDF_cm33_core0, LV_CONF_INCLUDE_SIMPLE=1, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, SDK_OS_FREE_RTOS
  c misc: -fno-common -fdata-sections -fno-builtin -mthumb
  c include: ../Core/board;../Core/source;../Core/CMSIS;../Core/component/lists;../Core/component/uart;../../custom;../Core/device;../Core/drivers;../Core/freertos/freertos-kernel/include;../Core/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure;../../generated;../../generated/guider_customer_fonts;../../generated/guider_fonts;../Core/lcdc;../Core/lvgl;../Core/lvgl/lvgl;../Core/lvgl/lvgl/src;../Core/lvgl/lvgl/src/font;../Core/touchpanel;../Core/utilities;../Core/video
  asm define: CPU_LPC55S69JBD100_cm33_core0, DEBUG, KEIL, DEBUG
  asm include: ../Core/source;../Core/freertos/freertos-kernel/include
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947/arm/MCXN947_cm33_core0_flash.scf
  link misc: --remove --entry=Reset_Handler --diag_suppress 6314 --predefine="-D__stack_size__=0x800"
--remove
  group board
    ../Core/board/: board.c board.h clock_config.c clock_config.h lvgl_support.c lvgl_support.h pin_mux.c pin_mux.h
  group CMSIS
    ../Core/CMSIS/: cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_version.h core_cm33.h mpu_armv8.h tz_context.h
  group component/lists
    ../Core/component/lists/: fsl_component_generic_list.c fsl_component_generic_list.h
  group component/uart
    ../Core/component/uart/: fsl_adapter_lpuart.c fsl_adapter_uart.h
  group custom
    ../../custom/: custom.c custom.h custom.mk lv_conf_ext.h
  group device
    ../Core/device/: fsl_device_registers.h MCXN947_cm33_core0.h MCXN947_cm33_core0_features.h system_MCXN947_cm33_core0.c system_MCXN947_cm33_core0.h
  group drivers
    ../Core/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_common_arm.c fsl_common_arm.h fsl_edma.c fsl_edma.h fsl_edma_core.h fsl_edma_soc.c fsl_edma_soc.h fsl_flexio.c fsl_flexio.h fsl_flexio_mculcd.c fsl_flexio_mculcd.h fsl_flexio_mculcd_edma.c fsl_flexio_mculcd_edma.h fsl_flexio_mculcd_smartdma.c fsl_flexio_mculcd_smartdma.h fsl_gpio.c fsl_gpio.h fsl_inputmux.c fsl_inputmux.h fsl_inputmux_connections.h fsl_lpflexcomm.c fsl_lpflexcomm.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpuart.c fsl_lpuart.h fsl_port.h fsl_reset.c fsl_reset.h fsl_smartdma.c fsl_smartdma.h fsl_smartdma_mcxn.c fsl_smartdma_mcxn.h fsl_smartdma_prv.h fsl_smartdma_rt500.c fsl_smartdma_rt500.h fsl_spc.c fsl_spc.h
  group freertos/freertos-kernel
    ../Core/freertos/freertos-kernel/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group freertos/freertos-kernel/include
    ../Core/freertos/freertos-kernel/include/: atomic.h croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h freertos_tasks_c_additions.h list.h message_buffer.h mpu_prototypes.h mpu_syscall_numbers.h mpu_wrappers.h newlib-freertos.h picolibc-freertos.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure
    ../Core/freertos/freertos-kernel/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c portasm.h portmacro.h portmacrocommon.h
  group freertos/freertos-kernel/portable/MemMang
    ../Core/freertos/freertos-kernel/portable/MemMang/: heap_4.c
  group freertos/freertos-kernel/portable
    ../Core/freertos/freertos-kernel/portable/: readme.txt
  group generated
    ../../generated/: events_init.c events_init.h fs_driver.py generated.mk gui_guider.c gui_guider.h gui_guider.py setup_scr_Home.c widgets_init.c widgets_init.h
  group generated\guider_customer_fonts
    ../../generated/guider_customer_fonts/: guider_customer_fonts.h guider_customer_fonts.mk
  group generated\guider_fonts
    ../../generated/guider_fonts/: fonts_list.mk guider_fonts.mk lv_font_montserratMedium_10.c lv_font_montserratMedium_13.c lv_font_montserratMedium_14.c lv_font_montserratMedium_15.c lv_font_montserratMedium_17.c lv_font_montserratMedium_18.c
  group generated\images
    ../../generated/images/: images.mk images_list.mk images_md5.json lottie_list.mk _download_alpha_12x12.c _download_alpha_13x13.c _home_bak_27x56.c _menu_air_54x54.c _menu_anfang_54x54.c _menu_bak_480x320.c _menu_bal_alpha_192x192.c _menu_electricity_54x54.c _menu_elevator_54x54.c _menu_light_54x54.c _menu_tem_54x54.c _menu_xiaofang_54x54.c _upload_alpha_12x12.c _upload_alpha_13x13.c
  group generated\MicroPython
    ../../generated/MicroPython/: images_md5.json lv_font_montserratMedium_10.fnt lv_font_montserratMedium_13.fnt lv_font_montserratMedium_14.fnt lv_font_montserratMedium_15.fnt lv_font_montserratMedium_17.fnt lv_font_montserratMedium_18.fnt _download_alpha_12x12.bin _download_alpha_13x13.bin _home_bak_27x56.bin _menu_air_54x54.bin _menu_anfang_54x54.bin _menu_bak_480x320.bin _menu_bal_alpha_192x192.bin _menu_electricity_54x54.bin _menu_elevator_54x54.bin _menu_light_54x54.bin _menu_tem_54x54.bin _menu_xiaofang_54x54.bin _upload_alpha_12x12.bin _upload_alpha_13x13.bin
  group lcdc
    ../Core/lcdc/: fsl_ssd1963.c fsl_ssd1963.h fsl_st7796s.c fsl_st7796s.h
  group lvgl/lvgl
    ../Core/lvgl/lvgl/: ChangeLogKSDK.txt LICENCE.txt lvgl.h
  group lvgl/lvgl/src/core
    ../Core/lvgl/lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group lvgl/lvgl/src/draw/arm2d
    ../Core/lvgl/lvgl/src/draw/arm2d/: lv_gpu_arm2d.h
  group lvgl/lvgl/src/draw
    ../Core/lvgl/lvgl/src/draw/: lv_draw.c lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_layer.c lv_draw_layer.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_transform.c lv_draw_transform.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h
  group lvgl/lvgl/src/draw/nxp/pxp
    ../Core/lvgl/lvgl/src/draw/nxp/pxp/: lv_draw_pxp.c lv_draw_pxp.h lv_draw_pxp_blend.c lv_draw_pxp_blend.h lv_gpu_nxp_pxp.c lv_gpu_nxp_pxp.h lv_gpu_nxp_pxp_osa.c lv_gpu_nxp_pxp_osa.h
  group lvgl/lvgl/src/draw/nxp/vglite
    ../Core/lvgl/lvgl/src/draw/nxp/vglite/: lv_draw_vglite.c lv_draw_vglite.h lv_draw_vglite_arc.c lv_draw_vglite_arc.h lv_draw_vglite_blend.c lv_draw_vglite_blend.h lv_draw_vglite_line.c lv_draw_vglite_line.h lv_draw_vglite_rect.c lv_draw_vglite_rect.h lv_vglite_buf.c lv_vglite_buf.h lv_vglite_utils.c lv_vglite_utils.h
  group lvgl/lvgl/src/draw/renesas
    ../Core/lvgl/lvgl/src/draw/renesas/: lv_gpu_d2_draw_label.c lv_gpu_d2_ra6m3.c lv_gpu_d2_ra6m3.h
  group lvgl/lvgl/src/draw/sdl
    ../Core/lvgl/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl.h lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_composite.h lv_draw_sdl_img.c lv_draw_sdl_img.h lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_layer.h lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_mask.h lv_draw_sdl_polygon.c lv_draw_sdl_priv.h lv_draw_sdl_rect.c lv_draw_sdl_rect.h lv_draw_sdl_stack_blur.c lv_draw_sdl_stack_blur.h lv_draw_sdl_texture_cache.c lv_draw_sdl_texture_cache.h lv_draw_sdl_utils.c lv_draw_sdl_utils.h
  group lvgl/lvgl/src/draw/stm32_dma2d
    ../Core/lvgl/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c lv_gpu_stm32_dma2d.h
  group lvgl/lvgl/src/draw/sw
    ../Core/lvgl/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw.h lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_blend.h lv_draw_sw_dither.c lv_draw_sw_dither.h lv_draw_sw_gradient.c lv_draw_sw_gradient.h lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group lvgl/lvgl/src/draw/swm341_dma2d
    ../Core/lvgl/lvgl/src/draw/swm341_dma2d/: lv_gpu_swm341_dma2d.h
  group lvgl/lvgl/src/extra/layouts/flex
    ../Core/lvgl/lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.h
  group lvgl/lvgl/src/extra/layouts/grid
    ../Core/lvgl/lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.h
  group lvgl/lvgl/src/extra/layouts
    ../Core/lvgl/lvgl/src/extra/layouts/: lv_layouts.h
  group lvgl/lvgl/src/extra/libs/barcode
    ../Core/lvgl/lvgl/src/extra/libs/barcode/: code128.c code128.h lv_barcode.c lv_barcode.h
  group lvgl/lvgl/src/extra/libs/bmp
    ../Core/lvgl/lvgl/src/extra/libs/bmp/: lv_bmp.c lv_bmp.h
  group lvgl/lvgl/src/extra/libs/ffmpeg
    ../Core/lvgl/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c lv_ffmpeg.h
  group lvgl/lvgl/src/extra/libs/freetype
    ../Core/lvgl/lvgl/src/extra/libs/freetype/: lv_freetype.c lv_freetype.h
  group lvgl/lvgl/src/extra/libs/fsdrv
    ../Core/lvgl/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_rawfs.c lv_fs_stdio.c lv_fs_win32.c lv_fsdrv.h
  group lvgl/lvgl/src/extra/libs/gif
    ../Core/lvgl/lvgl/src/extra/libs/gif/: gifdec.c gifdec.h lv_gif.c lv_gif.h
  group lvgl/lvgl/src/extra/libs
    ../Core/lvgl/lvgl/src/extra/libs/: lv_libs.h
  group lvgl/lvgl/src/extra/libs/png
    ../Core/lvgl/lvgl/src/extra/libs/png/: lodepng.c lodepng.h lv_png.c lv_png.h
  group lvgl/lvgl/src/extra/libs/qrcode
    ../Core/lvgl/lvgl/src/extra/libs/qrcode/: lv_qrcode.c lv_qrcode.h qrcodegen.c qrcodegen.h
  group lvgl/lvgl/src/extra/libs/rlottie
    ../Core/lvgl/lvgl/src/extra/libs/rlottie/: lv_rlottie.c lv_rlottie.h
  group lvgl/lvgl/src/extra/libs/sjpg
    ../Core/lvgl/lvgl/src/extra/libs/sjpg/: lv_sjpg.c lv_sjpg.h tjpgd.c tjpgd.h tjpgdcnf.h
  group lvgl/lvgl/src/extra
    ../Core/lvgl/lvgl/src/extra/: lv_extra.c lv_extra.h
  group lvgl/lvgl/src/extra/others/fragment
    ../Core/lvgl/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment.h lv_fragment_manager.c
  group lvgl/lvgl/src/extra/others/gridnav
    ../Core/lvgl/lvgl/src/extra/others/gridnav/: lv_gridnav.c lv_gridnav.h
  group lvgl/lvgl/src/extra/others/ime
    ../Core/lvgl/lvgl/src/extra/others/ime/: lv_ime_pinyin.c lv_ime_pinyin.h
  group lvgl/lvgl/src/extra/others/imgfont
    ../Core/lvgl/lvgl/src/extra/others/imgfont/: lv_imgfont.c lv_imgfont.h
  group lvgl/lvgl/src/extra/others
    ../Core/lvgl/lvgl/src/extra/others/: lv_others.h
  group lvgl/lvgl/src/extra/others/monkey
    ../Core/lvgl/lvgl/src/extra/others/monkey/: lv_monkey.c lv_monkey.h
  group lvgl/lvgl/src/extra/others/msg
    ../Core/lvgl/lvgl/src/extra/others/msg/: lv_msg.c lv_msg.h
  group lvgl/lvgl/src/extra/others/snapshot
    ../Core/lvgl/lvgl/src/extra/others/snapshot/: lv_snapshot.c lv_snapshot.h
  group lvgl/lvgl/src/extra/themes/basic
    ../Core/lvgl/lvgl/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
  group lvgl/lvgl/src/extra/themes/default
    ../Core/lvgl/lvgl/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
  group lvgl/lvgl/src/extra/themes
    ../Core/lvgl/lvgl/src/extra/themes/: lv_themes.h
  group lvgl/lvgl/src/extra/themes/mono
    ../Core/lvgl/lvgl/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group lvgl/lvgl/src/extra/widgets/analogclock
    ../Core/lvgl/lvgl/src/extra/widgets/analogclock/: lv_analogclock.c lv_analogclock.h
  group lvgl/lvgl/src/extra/widgets/animimg
    ../Core/lvgl/lvgl/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
  group lvgl/lvgl/src/extra/widgets/calendar
    ../Core/lvgl/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
  group lvgl/lvgl/src/extra/widgets/carousel
    ../Core/lvgl/lvgl/src/extra/widgets/carousel/: lv_carousel.c lv_carousel.h
  group lvgl/lvgl/src/extra/widgets/chart
    ../Core/lvgl/lvgl/src/extra/widgets/chart/: lv_chart.c lv_chart.h
  group lvgl/lvgl/src/extra/widgets/colorwheel
    ../Core/lvgl/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
  group lvgl/lvgl/src/extra/widgets/dclock
    ../Core/lvgl/lvgl/src/extra/widgets/dclock/: lv_dclock.c lv_dclock.h
  group lvgl/lvgl/src/extra/widgets/imgbtn
    ../Core/lvgl/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
  group lvgl/lvgl/src/extra/widgets/keyboard
    ../Core/lvgl/lvgl/src/extra/widgets/keyboard/: chinese_library.h lv_keyboard.c lv_keyboard.h lv_zh_keyboard.c lv_zh_keyboard.h
  group lvgl/lvgl/src/extra/widgets/led
    ../Core/lvgl/lvgl/src/extra/widgets/led/: lv_led.c lv_led.h
  group lvgl/lvgl/src/extra/widgets/list
    ../Core/lvgl/lvgl/src/extra/widgets/list/: lv_list.c lv_list.h
  group lvgl/lvgl/src/extra/widgets
    ../Core/lvgl/lvgl/src/extra/widgets/: lv_widgets.h
  group lvgl/lvgl/src/extra/widgets/menu
    ../Core/lvgl/lvgl/src/extra/widgets/menu/: lv_menu.c lv_menu.h
  group lvgl/lvgl/src/extra/widgets/meter
    ../Core/lvgl/lvgl/src/extra/widgets/meter/: lv_meter.c lv_meter.h
  group lvgl/lvgl/src/extra/widgets/msgbox
    ../Core/lvgl/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
  group lvgl/lvgl/src/extra/widgets/radiobtn
    ../Core/lvgl/lvgl/src/extra/widgets/radiobtn/: lv_radiobtn.c lv_radiobtn.h
  group lvgl/lvgl/src/extra/widgets/span
    ../Core/lvgl/lvgl/src/extra/widgets/span/: lv_span.c lv_span.h
  group lvgl/lvgl/src/extra/widgets/spinbox
    ../Core/lvgl/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
  group lvgl/lvgl/src/extra/widgets/spinner
    ../Core/lvgl/lvgl/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
  group lvgl/lvgl/src/extra/widgets/tabview
    ../Core/lvgl/lvgl/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
  group lvgl/lvgl/src/extra/widgets/textprogress
    ../Core/lvgl/lvgl/src/extra/widgets/textprogress/: lv_textprogress.c lv_textprogress.h
  group lvgl/lvgl/src/extra/widgets/tileview
    ../Core/lvgl/lvgl/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
  group lvgl/lvgl/src/extra/widgets/video
    ../Core/lvgl/lvgl/src/extra/widgets/video/: lv_video.c lv_video.h
  group lvgl/lvgl/src/extra/widgets/win
    ../Core/lvgl/lvgl/src/extra/widgets/win/: lv_win.c lv_win.h
  group lvgl/lvgl/src/font
    ../Core/lvgl/lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_montserrat_8.c lv_font_simsun_16_cjk.c lv_font_unscii_16.c lv_font_unscii_8.c lv_symbol_def.h
  group lvgl/lvgl/src/hal
    ../Core/lvgl/lvgl/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group lvgl/lvgl/src
    ../Core/lvgl/lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group lvgl/lvgl/src/misc
    ../Core/lvgl/lvgl/src/misc/: lv_anim.c lv_anim.h lv_anim_timeline.c lv_anim_timeline.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_lru.c lv_lru.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group lvgl/lvgl/src/widgets
    ../Core/lvgl/lvgl/src/widgets/: lv_arc.c lv_arc.h lv_bar.c lv_bar.h lv_btn.c lv_btn.h lv_btnmatrix.c lv_btnmatrix.h lv_canvas.c lv_canvas.h lv_checkbox.c lv_checkbox.h lv_dropdown.c lv_dropdown.h lv_img.c lv_img.h lv_label.c lv_label.h lv_line.c lv_line.h lv_objx_templ.c lv_objx_templ.h lv_roller.c lv_roller.h lv_slider.c lv_slider.h lv_switch.c lv_switch.h lv_table.c lv_table.h lv_textarea.c lv_textarea.h
  group source
    ../Core/source/: FreeRTOSConfig.h lv_conf.h lvgl_demo_utils.c lvgl_demo_utils.h lvgl_freertos.c lvgl_freertos.h lvgl_guider.c
  group startup
    startup/: startup_MCXN947_cm33_core0.S
  group touchpanel
    ../Core/touchpanel/: fsl_ft5406_rt.c fsl_ft5406_rt.h fsl_gt911.c fsl_gt911.h
  group utilities
    ../Core/utilities/: fsl_assert.c fsl_assert.h fsl_debug_console.c fsl_debug_console.h fsl_str.c fsl_str.h
  group video
    ../Core/video/: fsl_dbi.c fsl_dbi.h fsl_dbi_flexio_edma.c fsl_dbi_flexio_edma.h fsl_dbi_flexio_smartdma.c fsl_dbi_flexio_smartdma.h
target lvgl_guider release (ARM-ADS)
  device: MCXN947VDF:cm33_core0 NXP
  pack: NXP.MCXN947_DFP.16.0.0
  cpu: CPUTYPE("Cortex-M33") FPU3(SFPU) TZ DSP
  output: lvgl_guider.out
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: NDEBUG, CPU_MCXN947VDF_cm33_core0, LV_CONF_INCLUDE_SIMPLE=1, MCUXPRESSO_SDK, SDK_I2C_BASED_COMPONENT_USED=1, SDK_OS_FREE_RTOS
  c misc: -fno-common -fdata-sections -fno-builtin -mthumb
  c include: as above
  asm define: CPU_LPC55S69JBD100_cm33_core0, NDEBUG, KEIL, NDEBUG
  asm include: ../Core/source;../Core/freertos/freertos-kernel/include
  library: MicroLIB
  memory RVCT1: ROM 0x0 size 0x100000
  memory RVCT2: ROM 0x100000 size 0x100000
  memory RVCT4: ROM 0x3000000 size 0x40000
  memory RVCT5: ROM 0x13000000 size 0x40000
  memory RVCT6: RAM 0x20000000 size 0x68000
  memory RVCT7: RAM 0x4000000 size 0x18000
  memory RVCT8: RAM 0x14000000 size 0x18000
  memory RVCT9: RAM 0x10000000 size 0x100000
  memory RVCT10: RAM 0x10100000 size 0x100000
  scatter file: MCXN947/arm/MCXN947_cm33_core0_flash.scf
  link misc: as above
